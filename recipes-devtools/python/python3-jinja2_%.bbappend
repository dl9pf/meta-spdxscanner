BBCLASSEXTEND = "native"

RDEPENDS_${PN} = "python3-sphinx python3-markupsafe"
