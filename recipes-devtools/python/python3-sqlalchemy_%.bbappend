BBCLASSEXTEND = "native"

RDEPENDS_${PN}_remove = "python3-numbers python3-misc"
