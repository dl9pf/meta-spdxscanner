BBCLASSEXTEND = "native"

RDEPENDS_${PN} = "python-sphinx python-markupsafe"
