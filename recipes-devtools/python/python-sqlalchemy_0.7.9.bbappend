BBCLASSEXTEND = "native"

RDEPENDS_${PN}_remove = "python-numbers"
