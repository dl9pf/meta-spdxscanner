SRC_URI_native += " 0001-magic.py-modified-for-dosocs2.patch \
        "

